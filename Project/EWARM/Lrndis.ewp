# IAR project Lrndis.ewp, settings and files
configuration TE-STM32F103 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; USE_TE_STM32F103
  ICCARM.CCDiagSuppress: Pe236
  ICCARM.CCIncludePath2: ..\Src; ..\Inc; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32F1xx\Include; ..\..\Libraries\STM32F1xx_HAL_Driver\Inc; ..\..\Libraries\STM32F1xx_HAL_Driver\Inc\Legacy; ..\..\Libraries\STM32_USB_Device_Library\Core\Inc; ..\..\Libraries\STM32_USB_Device_Library\Class\AUDIO\Incx; ..\LRNDIS\Inc; ..\WEB\lwip-1.4.1\src\include; ..\WEB\lwip-1.4.1\src\include\lwip; ..\WEB\lwip-1.4.1\src\include\ipv4; ..\WEB\lwip-1.4.1\apps\httpserver_raw; ..\WEB\dhcp-server; ..\WEB\dns-server; ..\WEB; ..\..\Libraries\FatFs; ..\..\Libraries\FatFs\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lrndis.srec
  ILINK.IlinkOutputFile: audio103 Configuration.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
  group Application/User
    ../Src/: bsp_driver_sd.c communication.c fatfs.c hw_config.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c time.c
  group Drivers/CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sd.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group FatFs
    ../../Libraries/FatFs/option/: ccsbcs.c syscall.c
    ../../Libraries/FatFs/: diskio.c ff.c ff_gen_drv.c
    ../../Libraries/FatFs/drivers/: sd_diskio.c
  group Lrndis
    ../LRNDIS/Src/: usb_device.c usbd_conf.c usbd_desc.c usbd_rndis.c
  group USB_Device_Library
    ../../Libraries/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group WEB/dhcp
    ../WEB/dhcp-server/: dhserver.c
  group WEB/dns-server
    ../WEB/dns-server/: dnserver.c
  group WEB/http
    ../WEB/lwip-1.4.1/apps/httpserver_raw/: fs.c httpd.c
  group WEB/lwip/core
    ../WEB/lwip-1.4.1/src/core/: def.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group WEB/lwip/ipv4
    ../WEB/lwip-1.4.1/src/core/ipv4/: icmp.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group WEB/lwip/netif
    ../WEB/lwip-1.4.1/src/netif/: etharp.c
